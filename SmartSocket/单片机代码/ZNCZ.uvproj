# Keil uVision project ZNCZ.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C59 SST
  cpu: IRAM(0-0xFF) XRAM(0-0xff) IROM(0-0xFFFF) CLOCK(33000000)
  output: ZNCZ +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\src\hardware;.\src\Library
  group src
    ./src/: main.c guang.c kaiguan.c
  group Library
    ./src/Library/: clksource.c delay.c tim0.c uart0.c adc.c
  group hardware
    ./src/hardware/: JLX12864G.c ASCII8x16.c key.c DHT11.c ESP8266.c mqtt.c
