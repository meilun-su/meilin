# Keil uVision project 温度记录器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 温度记录器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 温度记录器.c DS1302.c ds18b20.c DEPUTY.H
